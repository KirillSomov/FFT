# Keil uVision project FFT.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MDR1986BE92 Milandr
  pack: Keil.MDR1986BExx.1.5.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FFT +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\lib\App;.\lib\Func;.\lib\HW
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group App
    ./lib/App/: link.h main.c
  group Func
    ./lib/Func/: FFT.c FFT.h
  group HW
    ./lib/HW/: ADC.c ADC.h CPU.c CPU.h LCD_ILI9341.c LCD_ILI9341.h SPI.c SPI.h Touch_FT6236.c Touch_FT6236.h Timer.c Timer.h Port_Cfg.c Port_Cfg.h Port_Setup.c Port_Setup.h
software components: CMSIS:CORE 5.2.0, Device:Startup 1.5
